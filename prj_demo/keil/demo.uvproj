# Keil uVision project demo.uvproj, settings and files
target ble_demo (ARM-ADS)
  device: QN9020 Quintic
  cpu: IRAM(0x10008000-0x1000FFFF) IROM(0x10000000-0x10007FFF) CLOCK(16000000) CPUTYPE("Cortex-M0")
  output: qpps
  AfterMake: fromelf --bin --output ./bin/qpps.bin ./obj/qpps.axf
  c flags: Optim=4 OneElfS=1
  c misc: --C99
  c include: ..\..\src\fw;..\..\src\profiles;..\..\src\profiles\qpp;..\..\src\profiles\qpp\qpps;..\..\src\profiles\dis\diss;..\..\src\app;..\..\src\app\gap;..\..\src\app\gatt;..\..\src\app\smp;..\..\src\app\qpps;..\..\src\app\diss;..\..\src\cmsis;..\..\src\driver;..\..\src\lib;..\..\src\qnevb;..\src;..\src\__test;..\..\src\app\otas;..\..\src\profiles\ota\otas;..\..\src\app\proxr;..\..\src\profiles\prox\proxr;..\..\src\profiles\bas\bass;..\..\src\app\bass
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  scatter file: ..\..\src\link\keil\qn9020_link.sct
  link misc: --no_autoat --remove
  group startup
    ../../src/startup/keil/: startup.s
  group main
    ../../src/main/: app_main.c
  group usr
    ../src/: system.c usr_design.c usr_proxr.c usr_bass.c
    ../src/__test/: test_timer.c
  group app
    ../../src/app/: app_util.c app_env.c app_printf.c app_sys.c app_task.c
    ../../src/app/gap/: app_gap.c app_gap_task.c
    ../../src/app/gatt/: app_gatt.c app_gatt_task.c
    ../../src/app/smp/: app_smp.c app_smp_task.c
    ../../src/app/diss/: app_diss.c app_diss_task.c
    ../../src/app/qpps/: app_qpps.c app_qpps_task.c
    ../../src/app/otas/: app_otas_task.c
    ../../src/app/proxr/: app_proxr_task.c app_proxr.c
    ../../src/app/bass/: app_bass.c app_bass_task.c
  group profiles
    ../../src/profiles/: prf_utils.c
    ../../src/profiles/dis/diss/: diss.c diss_task.c
    ../../src/profiles/qpp/qpps/: qpps.c qpps_task.c
    ../../src/profiles/prox/proxr/: proxr.c proxr_task.c
    ../../src/profiles/bas/bass/: bass.c bass_task.c
  group drivers
    ../../src/driver/: uart.c gpio.c sleep.c syscon.c wdt.c timer.c rtc.c serialflash.c pwm.c adc.c analog.c
  group lib
    ../../src/lib/keil/: qn9020b2_lib_peripheral.lib
    ../../src/profiles/ota/otas/: qn_ota.lib
  group qnevb
    ../../src/qnevb/: led.c button.c buzz.c
  group retarget
    ../../src/retarget/: retarget.c
